# IAR project cc31000_starter.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; _POSIX_SOURCE; UART_BUFFERED; TARGET_IS_TM4C123_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\; ..\..\..\..; ..\cc3100; ..\cc3100\platform\ek-tm4c123gxl; ..\cc3100\simplelink\include; ..\cc3100\simplelink\source
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cc31000_starter.bin
  ILINK.IlinkOutputFile: cc31000_starter.out
  ILINK.IlinkIcfFile: cc31000_starter.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ../cc3100/platform/ek-tm4c123gxl/: board.c spi.c uart.c
    ../../../../utils/: cmdline.c uartstdio.c ustdlib.c
    ../cc3100/simplelink/source/: device.c driver.c flowcont.c fs.c netapp.c netcfg.c nonos.c socket.c spawn.c wlan.c
    ./: starter.c startup_ewarm.c
