# Keil uVision project TwoButtonPoll.uvproj, settings and files
target TwoButtonPoll (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: TwoButtonPoll
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s DAC.c Lab5.c Music.c PLL.c ST7735.c Switch.c Timer0A.c DAC.h Music.h PLL.h ST7735.h Switch.h Timer0A.h SysTick.h SysTick.c Timer1A.c plotImage.c plotImage.h
